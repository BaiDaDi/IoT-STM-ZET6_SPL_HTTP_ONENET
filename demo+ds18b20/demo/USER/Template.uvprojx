# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\CORE;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\ESP8266;..\HARDWARE\TIMER7;..\HARDWARE\USART3;..\HARDWARE\KEY;..\HARDWARE\DHT11;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\LSENS;..\HARDWARE\DS18B20;..\HARDWARE\MQ2;..\HARDWARE\DMA
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/TIMER7/: timer.c
    ../HARDWARE/ESP8266/: esp8266.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/LSENS/: lsens.c
    ../HARDWARE/ADC/: adc.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/MQ2/: MQ2.c
    ../HARDWARE/DMA/: DMA.c
